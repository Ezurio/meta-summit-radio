SUMMARY = "Summit 60 Firmware for SOM8MP"

require radio-firmware.inc
require radio-stack-version.inc

LICENSE += "& NXP1"
NO_GENERIC_LICENSE[NXP1] = "LICENSE.nxp1"
LIC_FILES_CHKSUM += "file://LICENSE.nxp1;md5=933884af53a2d9e6d73e4e3065819f40"
