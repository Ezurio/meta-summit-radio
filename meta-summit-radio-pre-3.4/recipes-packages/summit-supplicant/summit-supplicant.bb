SUMMARY = "Summit Supplicant"

require summit-supplicant.inc
require radio-stack-version.inc

DEFCONFIG = "config_openssl"

DEPENDS += "dbus"
